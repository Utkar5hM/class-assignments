# Keil uVision project lab3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: lab3
  c flags: Optim=1 v6Lang=1 v6LangP=1
  group Source Group 1
    ./3_7/: b.s
