# Keil uVision project prj1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: prj1
  c flags: Optim=1
  group Source Group 1
    ./: First_Program_164_109.s
