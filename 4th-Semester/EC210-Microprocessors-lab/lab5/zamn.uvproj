# Keil uVision project zamn.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: zamn
  c flags: Optim=1
  group Source Group 1
    ./: q1.s
